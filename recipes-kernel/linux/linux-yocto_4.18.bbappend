require linux-yocto-intel-x86.inc

KBRANCH_intel-x86  = "v4.18/standard/intel-x86"
