require linux-yocto-intel-x86.inc

KBRANCH_intel-x86  = "v5.10/standard/preempt-rt/x86"

LINUX_VERSION_intel-x86 ?= "5.10.x"
