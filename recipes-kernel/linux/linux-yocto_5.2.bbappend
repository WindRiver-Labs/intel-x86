require linux-yocto-intel-x86.inc

KBRANCH_intel-x86  = "v5.2/standard/intel-x86"
