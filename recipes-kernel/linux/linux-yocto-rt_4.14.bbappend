require linux-yocto-intel-x86.inc

KBRANCH_intel-x86  = "v4.14/standard/preempt-rt/base"
SRCREV_machine = "${AUTOREV}"
SRCREV_meta = "${AUTOREV}"
