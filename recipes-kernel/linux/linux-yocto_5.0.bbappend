require linux-yocto-intel-x86.inc

KBRANCH_intel-x86  = "v5.0/standard/intel-x86"
