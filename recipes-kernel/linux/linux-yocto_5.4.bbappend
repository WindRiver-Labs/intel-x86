require linux-yocto-intel-x86.inc

KBRANCH_intel-x86  = "v5.4/standard/intel-x86"

LINUX_VERSION_intel-x86 ?= "5.4.x"
