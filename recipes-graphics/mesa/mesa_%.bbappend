EXTRA_OEMESON_append_intel-x86-64 = " -Dprefer-iris=true"
GALLIUMDRIVERS_append_intel-x86-64 = ",iris"
